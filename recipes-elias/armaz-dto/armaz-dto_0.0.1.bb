SUMMARY = "Armaz device tree"
DESCRIPTION = "Device tree for Armaz."
HOMEPAGE = "http://www.exmachina.fr/"
SECTION = "libs"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SRCREV = "d211f69cd36497053e8f4b3cc25286bb1825e0d3"

PR = "r1"
PV = "0.0.1"

_DTO_REV = "00A0"

require armaz-dto.inc
