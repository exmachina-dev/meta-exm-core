GLIBC_EXTRA_OECONF += "--enable-shared"
